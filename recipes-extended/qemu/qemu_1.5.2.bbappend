EXTRA_OECONF ='--enable-spice --extra-cflags="-I/home/user/hype-scripts/build/tmp.oe-hype-eglibc/work/x86_64-oe-linux/xen/4.3.0-r0/xen-4.3.0/tools/include -I/home/user/hype-scripts/build/tmp.oe-hype-eglibc/work/x86_64-oe-linux/xen/4.3.0-r0/xen-4.3.0/tools/libxc -I/home/user/hype-scripts/build/tmp.oe-hype-eglibc/work/x86_64-oe-linux/xen/4.3.0-r0/xen-4.3.0/tools/xenstore" --extra-ldflags="-L/home/user/hype-scripts/build/tmp.oe-hype-eglibc/work/x86_64-oe-linux/xen/4.3.0-r0/xen-4.3.0/tools/libxc -L/home/user/hype-scripts/build/tmp.oe-hype-eglibc/work/x86_64-oe-linux/xen/4.3.0-r0/xen-4.3.0/tools/xenstore"'
